require linux-tpl_4.9.inc

LINUX_KERNEL_TYPE = "standard"
KERNEL_IMAGETYPE = "vmlinux"
